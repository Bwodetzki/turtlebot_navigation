Commit message: rescaled plane to fit larger environment size

File: data/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision plane normal=0 0 1; visual mesh filename=plane.obj scale=3 3 1
